CIRCUIT C:\users\huthayfa\Desktop\CarrySaveArrayMul.MSK
*
* IC Technology: CMOS 22nm - 10 Metal copper - doube gate
*
VDD 1 0 DC 0.70
VIA0 202 0 DC 0 PULSE(0.00 0.70 0.03N 0.00N 0.00N 0.04N 0.07N)
VIA1 203 0 DC 0 PULSE(0.00 0.70 0.06N 0.00N 0.00N 0.08N 0.14N)
VIA2 204 0 DC 0 PULSE(0.00 0.70 0.12N 0.00N 0.00N 0.16N 0.28N)
VIA3 205 0 DC 0 PULSE(0.00 0.70 0.24N 0.00N 0.00N 0.32N 0.56N)
VIB0 206 0 DC 0 PULSE(0.00 0.70 0.03N 0.00N 0.00N 0.04N 0.07N)
VIB1 207 0 DC 0 PULSE(0.00 0.70 0.06N 0.00N 0.00N 0.08N 0.14N)
VIB2 208 0 DC 0 PULSE(0.00 0.70 0.12N 0.00N 0.00N 0.16N 0.28N)
VIB3 209 0 DC 0 PULSE(0.00 0.70 0.24N 0.00N 0.00N 0.32N 0.56N)
VC 303 0 DC 0 PULSE(0.00 0.70 0.32N 0.00N 0.00N 0.32N 0.64N)
VC 304 0 DC 0 PULSE(0.00 0.70 0.32N 0.00N 0.00N 0.32N 0.64N)
VA 305 0 DC 0 PULSE(0.00 0.70 0.08N 0.00N 0.00N 0.08N 0.16N)
VB 306 0 DC 0 PULSE(0.00 0.70 0.16N 0.00N 0.00N 0.16N 0.32N)
Vclk 308 0 DC 0 PULSE(0.00 0.70 0.04N 0.00N 0.00N 0.04N 0.08N)
Vclk' 309 0 DC 0 PULSE(0.70 0.00 0.04N 0.00N 0.00N 0.04N 0.08N)
VC 310 0 DC 0 PULSE(0.00 0.70 0.32N 0.00N 0.00N 0.32N 0.64N)
VA 311 0 DC 0 PULSE(0.00 0.70 0.08N 0.00N 0.00N 0.08N 0.16N)
VB 312 0 DC 0 PULSE(0.00 0.70 0.16N 0.00N 0.00N 0.16N 0.32N)
VC 314 0 DC 0 PULSE(0.00 0.70 0.32N 0.00N 0.00N 0.32N 0.64N)
VA 315 0 DC 0 PULSE(0.00 0.70 0.08N 0.00N 0.00N 0.08N 0.16N)
VB 316 0 DC 0 PULSE(0.00 0.70 0.16N 0.00N 0.00N 0.16N 0.32N)
VC 318 0 DC 0 PULSE(0.00 0.70 0.32N 0.00N 0.00N 0.32N 0.64N)
VA 319 0 DC 0 PULSE(0.00 0.70 0.08N 0.00N 0.00N 0.08N 0.16N)
VB 320 0 DC 0 PULSE(0.00 0.70 0.16N 0.00N 0.00N 0.16N 0.32N)
VC 321 0 DC 0 PULSE(0.00 0.70 0.32N 0.00N 0.00N 0.32N 0.64N)
VA 322 0 DC 0 PULSE(0.00 0.70 0.08N 0.00N 0.00N 0.08N 0.16N)
VB 323 0 DC 0 PULSE(0.00 0.70 0.16N 0.00N 0.00N 0.16N 0.32N)
VA 324 0 DC 0 PULSE(0.00 0.70 0.02N 0.00N 0.00N 0.02N 0.04N)
VB 325 0 DC 0 PULSE(0.00 0.70 0.04N 0.00N 0.00N 0.04N 0.08N)
VA 328 0 DC 0 PULSE(0.00 0.70 0.08N 0.00N 0.00N 0.08N 0.16N)
VB 329 0 DC 0 PULSE(0.00 0.70 0.16N 0.00N 0.00N 0.16N 0.32N)
*
* List of nodes
* "Carry" corresponds to n°35, WARNING: appears 12 times in the layout
* "Carry" corresponds to n°36, WARNING: appears 12 times in the layout
* "Carry" corresponds to n°37, WARNING: appears 12 times in the layout
* "Carry" corresponds to n°38, WARNING: appears 12 times in the layout
* "Carry" corresponds to n°39, WARNING: appears 12 times in the layout
* "Carry" corresponds to n°40, WARNING: appears 12 times in the layout
* "S" corresponds to n°46, WARNING: appears 12 times in the layout
* "S" corresponds to n°52, WARNING: appears 12 times in the layout
* "S" corresponds to n°53, WARNING: appears 12 times in the layout
* "S" corresponds to n°54, WARNING: appears 12 times in the layout
* "S" corresponds to n°56, WARNING: appears 12 times in the layout
* "S" corresponds to n°57, WARNING: appears 12 times in the layout
* "Carry" corresponds to n°83, WARNING: appears 12 times in the layout
* "Carry" corresponds to n°84, WARNING: appears 12 times in the layout
* "Carry" corresponds to n°85, WARNING: appears 12 times in the layout
* "S" corresponds to n°92, WARNING: appears 12 times in the layout
* "S" corresponds to n°93, WARNING: appears 12 times in the layout
* "Carry" corresponds to n°94, WARNING: appears 12 times in the layout
* "S" corresponds to n°95, WARNING: appears 12 times in the layout
* "Carry" corresponds to n°96, WARNING: appears 12 times in the layout
* "Carry" corresponds to n°97, WARNING: appears 12 times in the layout
* "S" corresponds to n°98, WARNING: appears 12 times in the layout
* "N100" corresponds to n°100
* "N101" corresponds to n°101
* "S" corresponds to n°102, WARNING: appears 12 times in the layout
* "S" corresponds to n°103, WARNING: appears 12 times in the layout
* "N104" corresponds to n°104
* "N105" corresponds to n°105
* "N106" corresponds to n°106
* "N107" corresponds to n°107
* "N108" corresponds to n°108
* "N109" corresponds to n°109
* "N110" corresponds to n°110
* "N111" corresponds to n°111
* "N112" corresponds to n°112
* "N113" corresponds to n°113
* "N114" corresponds to n°114
* "N115" corresponds to n°115
* "N116" corresponds to n°116
* "N117" corresponds to n°117
* "N118" corresponds to n°118
* "N119" corresponds to n°119
* "N120" corresponds to n°120
* "N121" corresponds to n°121
* "00" corresponds to n°122
* "01" corresponds to n°123
* "02" corresponds to n°124
* "03" corresponds to n°125
* "10" corresponds to n°126
* "11" corresponds to n°127
* "12" corresponds to n°128
* "13" corresponds to n°129
* "20" corresponds to n°130
* "21" corresponds to n°131
* "22" corresponds to n°132
* "23" corresponds to n°133
* "30" corresponds to n°134
* "31" corresponds to n°135
* "32" corresponds to n°136
* "33" corresponds to n°137
* "N138" corresponds to n°138
* "N139" corresponds to n°139
* "N140" corresponds to n°140
* "N141" corresponds to n°141
* "N142" corresponds to n°142
* "N143" corresponds to n°143
* "N144" corresponds to n°144
* "N145" corresponds to n°145
* "N146" corresponds to n°146
* "N147" corresponds to n°147
* "N148" corresponds to n°148
* "N149" corresponds to n°149
* "N150" corresponds to n°150
* "N151" corresponds to n°151
* "N152" corresponds to n°152
* "N153" corresponds to n°153
* "A0" corresponds to n°154
* "A1" corresponds to n°155
* "A2" corresponds to n°156
* "A3" corresponds to n°157
* "B0" corresponds to n°158
* "B1" corresponds to n°159
* "B2" corresponds to n°160
* "B3" corresponds to n°161
* "N162" corresponds to n°162
* "N163" corresponds to n°163
* "N164" corresponds to n°164
* "N165" corresponds to n°165
* "N166" corresponds to n°166
* "N167" corresponds to n°167
* "N168" corresponds to n°168
* "N169" corresponds to n°169
* "N170" corresponds to n°170
* "N171" corresponds to n°171
* "N172" corresponds to n°172
* "N173" corresponds to n°173
* "N174" corresponds to n°174
* "N175" corresponds to n°175
* "N176" corresponds to n°176
* "N177" corresponds to n°177
* "N178" corresponds to n°178
* "N179" corresponds to n°179
* "N180" corresponds to n°180
* "N181" corresponds to n°181
* "N182" corresponds to n°182
* "N183" corresponds to n°183
* "N184" corresponds to n°184
* "N185" corresponds to n°185
* "N186" corresponds to n°186
* "N187" corresponds to n°187
* "N188" corresponds to n°188
* "N189" corresponds to n°189
* "N190" corresponds to n°190
* "N191" corresponds to n°191
* "N192" corresponds to n°192
* "N193" corresponds to n°193
* "N194" corresponds to n°194
* "N195" corresponds to n°195
* "N196" corresponds to n°196
* "N197" corresponds to n°197
* "N198" corresponds to n°198
* "N199" corresponds to n°199
* "N200" corresponds to n°200
* "N201" corresponds to n°201
* "IA0" corresponds to n°202
* "IA1" corresponds to n°203
* "IA2" corresponds to n°204
* "IA3" corresponds to n°205
* "IB0" corresponds to n°206
* "IB1" corresponds to n°207
* "IB2" corresponds to n°208
* "IB3" corresponds to n°209
* "N210" corresponds to n°210
* "N211" corresponds to n°211
* "N212" corresponds to n°212
* "N213" corresponds to n°213
* "N214" corresponds to n°214
* "N221" corresponds to n°221
* "N222" corresponds to n°222
* "N223" corresponds to n°223
* "N224" corresponds to n°224
* "N225" corresponds to n°225
* "N226" corresponds to n°226
* "N227" corresponds to n°227
* "N228" corresponds to n°228
* "N229" corresponds to n°229
* "N230" corresponds to n°230
* "N231" corresponds to n°231
* "N232" corresponds to n°232
* "N233" corresponds to n°233
* "N234" corresponds to n°234
* "N235" corresponds to n°235
* "N236" corresponds to n°236
* "N237" corresponds to n°237
* "N238" corresponds to n°238
* "N239" corresponds to n°239
* "N240" corresponds to n°240
* "N241" corresponds to n°241
* "N242" corresponds to n°242
* "N243" corresponds to n°243
* "N244" corresponds to n°244
* "N245" corresponds to n°245
* "N249" corresponds to n°249
* "N250" corresponds to n°250
* "N251" corresponds to n°251
* "N253" corresponds to n°253
* "N254" corresponds to n°254
* "N255" corresponds to n°255
* "N258" corresponds to n°258
* "N259" corresponds to n°259
* "N260" corresponds to n°260
* "N261" corresponds to n°261
* "N262" corresponds to n°262
* "N263" corresponds to n°263
* "N264" corresponds to n°264
* "N265" corresponds to n°265
* "N266" corresponds to n°266
* "N267" corresponds to n°267
* "N268" corresponds to n°268
* "N269" corresponds to n°269
* "N279" corresponds to n°279
* "N280" corresponds to n°280
* "N281" corresponds to n°281
* "N282" corresponds to n°282
* "N283" corresponds to n°283
* "N284" corresponds to n°284
* "N285" corresponds to n°285
* "N286" corresponds to n°286
* "N287" corresponds to n°287
* "N288" corresponds to n°288
* "N289" corresponds to n°289
* "N290" corresponds to n°290
* "N291" corresponds to n°291
* "N292" corresponds to n°292
* "N293" corresponds to n°293
* "N294" corresponds to n°294
* "C" corresponds to n°303, WARNING: appears 6 times in the layout
* "C" corresponds to n°304, WARNING: appears 6 times in the layout
* "A" corresponds to n°305, WARNING: appears 7 times in the layout
* "B" corresponds to n°306, WARNING: appears 7 times in the layout
* "N307" corresponds to n°307
* "clk" corresponds to n°308
* "clk'" corresponds to n°309
* "C" corresponds to n°310, WARNING: appears 6 times in the layout
* "A" corresponds to n°311, WARNING: appears 7 times in the layout
* "B" corresponds to n°312, WARNING: appears 7 times in the layout
* "N313" corresponds to n°313
* "C" corresponds to n°314, WARNING: appears 6 times in the layout
* "A" corresponds to n°315, WARNING: appears 7 times in the layout
* "B" corresponds to n°316, WARNING: appears 7 times in the layout
* "N317" corresponds to n°317
* "C" corresponds to n°318, WARNING: appears 6 times in the layout
* "A" corresponds to n°319, WARNING: appears 7 times in the layout
* "B" corresponds to n°320, WARNING: appears 7 times in the layout
* "C" corresponds to n°321, WARNING: appears 6 times in the layout
* "A" corresponds to n°322, WARNING: appears 7 times in the layout
* "B" corresponds to n°323, WARNING: appears 7 times in the layout
* "A" corresponds to n°324, WARNING: appears 7 times in the layout
* "B" corresponds to n°325, WARNING: appears 7 times in the layout
* "N326" corresponds to n°326
* "N327" corresponds to n°327
* "A" corresponds to n°328, WARNING: appears 7 times in the layout
* "B" corresponds to n°329, WARNING: appears 7 times in the layout
* "N330" corresponds to n°330
* "N331" corresponds to n°331
* "N332" corresponds to n°332
* "N333" corresponds to n°333
* "N334" corresponds to n°334
* "N335" corresponds to n°335
* "N336" corresponds to n°336
* "N337" corresponds to n°337
* "N338" corresponds to n°338
*
* MOS devices
MN1 35 41 210 0 N1  W= 0.10U L= 0.02U
MN2 36 317 211 0 N1  W= 0.10U L= 0.02U
MN3 37 307 212 0 N1  W= 0.10U L= 0.02U
MN4 38 313 213 0 N1  W= 0.10U L= 0.02U
MN5 39 45 214 0 N1  W= 0.10U L= 0.02U
MN6 210 70 35 0 N1  W= 0.10U L= 0.02U
MN7 211 71 36 0 N1  W= 0.10U L= 0.02U
MN8 212 72 37 0 N1  W= 0.10U L= 0.02U
MN9 213 73 38 0 N1  W= 0.10U L= 0.02U
MN10 214 74 39 0 N1  W= 0.10U L= 0.02U
MN11 0 75 210 0 N1  W= 0.10U L= 0.02U
MN12 0 76 211 0 N1  W= 0.10U L= 0.02U
MN13 0 77 212 0 N1  W= 0.10U L= 0.02U
MN14 0 78 213 0 N1  W= 0.10U L= 0.02U
MN15 0 79 214 0 N1  W= 0.10U L= 0.02U
MN16 41 318 0 0 N1  W= 0.10U L= 0.02U
MN17 42 314 0 0 N1  W= 0.10U L= 0.02U
MN18 43 304 0 0 N1  W= 0.10U L= 0.02U
MN19 0 64 40 0 N1  W= 0.10U L= 0.02U
MN20 44 310 0 0 N1  W= 0.10U L= 0.02U
MN21 45 321 0 0 N1  W= 0.10U L= 0.02U
MN22 46 58 0 0 N1  W= 0.10U L= 0.02U
MN23 52 318 221 0 N1  W= 0.10U L= 0.02U
MN24 53 314 222 0 N1  W= 0.10U L= 0.02U
MN25 54 304 223 0 N1  W= 0.10U L= 0.02U
MN26 56 310 224 0 N1  W= 0.10U L= 0.02U
MN27 57 321 225 0 N1  W= 0.10U L= 0.02U
MN28 221 70 52 0 N1  W= 0.10U L= 0.02U
MN29 222 71 53 0 N1  W= 0.10U L= 0.02U
MN30 223 72 54 0 N1  W= 0.10U L= 0.02U
MN31 58 325 226 0 N1  W= 0.10U L= 0.02U
MN32 224 73 56 0 N1  W= 0.10U L= 0.02U
MN33 225 74 57 0 N1  W= 0.10U L= 0.02U
MN34 0 59 221 0 N1  W= 0.10U L= 0.02U
MN35 0 60 222 0 N1  W= 0.10U L= 0.02U
MN36 0 61 223 0 N1  W= 0.10U L= 0.02U
MN37 226 324 58 0 N1  W= 0.10U L= 0.02U
MN38 0 62 224 0 N1  W= 0.10U L= 0.02U
MN39 0 63 225 0 N1  W= 0.10U L= 0.02U
MN40 227 70 0 0 N1  W= 0.10U L= 0.02U
MN41 228 71 0 0 N1  W= 0.10U L= 0.02U
MN42 229 72 0 0 N1  W= 0.10U L= 0.02U
MN43 0 64 226 0 N1  W= 0.10U L= 0.02U
MN44 230 73 0 0 N1  W= 0.10U L= 0.02U
MN45 231 74 0 0 N1  W= 0.10U L= 0.02U
MN46 59 318 227 0 N1  W= 0.10U L= 0.02U
MN47 60 314 228 0 N1  W= 0.10U L= 0.02U
MN48 61 304 229 0 N1  W= 0.10U L= 0.02U
MN49 232 324 0 0 N1  W= 0.10U L= 0.02U
MN50 62 310 230 0 N1  W= 0.10U L= 0.02U
MN51 63 321 231 0 N1  W= 0.10U L= 0.02U
MN52 64 325 232 0 N1  W= 0.10U L= 0.02U
MN53 70 320 233 0 N1  W= 0.10U L= 0.02U
MN54 71 316 234 0 N1  W= 0.10U L= 0.02U
MN55 72 306 235 0 N1  W= 0.10U L= 0.02U
MN56 73 312 236 0 N1  W= 0.10U L= 0.02U
MN57 74 323 237 0 N1  W= 0.10U L= 0.02U
MN58 233 319 70 0 N1  W= 0.10U L= 0.02U
MN59 234 315 71 0 N1  W= 0.10U L= 0.02U
MN60 235 305 72 0 N1  W= 0.10U L= 0.02U
MN61 236 311 73 0 N1  W= 0.10U L= 0.02U
MN62 237 322 74 0 N1  W= 0.10U L= 0.02U
MN63 0 75 233 0 N1  W= 0.10U L= 0.02U
MN64 0 76 234 0 N1  W= 0.10U L= 0.02U
MN65 0 77 235 0 N1  W= 0.10U L= 0.02U
MN66 0 78 236 0 N1  W= 0.10U L= 0.02U
MN67 0 79 237 0 N1  W= 0.10U L= 0.02U
MN68 238 319 0 0 N1  W= 0.10U L= 0.02U
MN69 239 315 0 0 N1  W= 0.10U L= 0.02U
MN70 240 305 0 0 N1  W= 0.10U L= 0.02U
MN71 241 311 0 0 N1  W= 0.10U L= 0.02U
MN72 242 322 0 0 N1  W= 0.10U L= 0.02U
MN73 75 320 238 0 N1  W= 0.10U L= 0.02U
MN74 76 316 239 0 N1  W= 0.10U L= 0.02U
MN75 77 306 240 0 N1  W= 0.10U L= 0.02U
MN76 78 312 241 0 N1  W= 0.10U L= 0.02U
MN77 79 323 242 0 N1  W= 0.10U L= 0.02U
MN78 83 86 243 0 N1  W= 0.10U L= 0.02U
MN79 84 87 244 0 N1  W= 0.10U L= 0.02U
MN80 85 88 245 0 N1  W= 0.10U L= 0.02U
MN81 243 111 83 0 N1  W= 0.10U L= 0.02U
MN82 244 112 84 0 N1  W= 0.10U L= 0.02U
MN83 245 113 85 0 N1  W= 0.10U L= 0.02U
MN84 0 117 243 0 N1  W= 0.10U L= 0.02U
MN85 0 118 244 0 N1  W= 0.10U L= 0.02U
MN86 0 119 245 0 N1  W= 0.10U L= 0.02U
MN87 86 96 0 0 N1  W= 0.10U L= 0.02U
MN88 87 97 0 0 N1  W= 0.10U L= 0.02U
MN89 88 303 0 0 N1  W= 0.10U L= 0.02U
MN90 92 96 249 0 N1  W= 0.10U L= 0.02U
MN91 93 97 250 0 N1  W= 0.10U L= 0.02U
MN92 95 303 251 0 N1  W= 0.10U L= 0.02U
MN93 249 111 92 0 N1  W= 0.10U L= 0.02U
MN94 250 112 93 0 N1  W= 0.10U L= 0.02U
MN95 251 113 95 0 N1  W= 0.10U L= 0.02U
MN96 0 99 249 0 N1  W= 0.10U L= 0.02U
MN97 0 100 250 0 N1  W= 0.10U L= 0.02U
MN98 0 116 94 0 N1  W= 0.10U L= 0.02U
MN99 0 101 251 0 N1  W= 0.10U L= 0.02U
MN100 253 111 0 0 N1  W= 0.10U L= 0.02U
MN101 254 112 0 0 N1  W= 0.10U L= 0.02U
MN102 98 107 0 0 N1  W= 0.10U L= 0.02U
MN103 255 113 0 0 N1  W= 0.10U L= 0.02U
MN104 0 120 96 0 N1  W= 0.10U L= 0.02U
MN105 0 121 97 0 N1  W= 0.10U L= 0.02U
MN106 99 96 253 0 N1  W= 0.10U L= 0.02U
MN107 100 97 254 0 N1  W= 0.10U L= 0.02U
MN108 101 303 255 0 N1  W= 0.10U L= 0.02U
MN109 102 114 0 0 N1  W= 0.10U L= 0.02U
MN110 103 115 0 0 N1  W= 0.10U L= 0.02U
MN111 107 327 258 0 N1  W= 0.10U L= 0.02U
MN112 111 130 259 0 N1  W= 0.10U L= 0.02U
MN113 112 330 260 0 N1  W= 0.10U L= 0.02U
MN114 258 326 107 0 N1  W= 0.10U L= 0.02U
MN115 113 329 261 0 N1  W= 0.10U L= 0.02U
MN116 114 123 262 0 N1  W= 0.10U L= 0.02U
MN117 115 124 263 0 N1  W= 0.10U L= 0.02U
MN118 259 103 111 0 N1  W= 0.10U L= 0.02U
MN119 260 98 112 0 N1  W= 0.10U L= 0.02U
MN120 0 116 258 0 N1  W= 0.10U L= 0.02U
MN121 261 328 113 0 N1  W= 0.10U L= 0.02U
MN122 262 126 114 0 N1  W= 0.10U L= 0.02U
MN123 263 127 115 0 N1  W= 0.10U L= 0.02U
MN124 0 117 259 0 N1  W= 0.10U L= 0.02U
MN125 0 118 260 0 N1  W= 0.10U L= 0.02U
MN126 264 326 0 0 N1  W= 0.10U L= 0.02U
MN127 0 119 261 0 N1  W= 0.10U L= 0.02U
MN128 0 120 262 0 N1  W= 0.10U L= 0.02U
MN129 0 121 263 0 N1  W= 0.10U L= 0.02U
MN130 265 103 0 0 N1  W= 0.10U L= 0.02U
MN131 266 98 0 0 N1  W= 0.10U L= 0.02U
MN132 116 327 264 0 N1  W= 0.10U L= 0.02U
MN133 267 328 0 0 N1  W= 0.10U L= 0.02U
MN134 268 126 0 0 N1  W= 0.10U L= 0.02U
MN135 269 127 0 0 N1  W= 0.10U L= 0.02U
MN136 117 130 265 0 N1  W= 0.10U L= 0.02U
MN137 118 330 266 0 N1  W= 0.10U L= 0.02U
MN138 119 329 267 0 N1  W= 0.10U L= 0.02U
MN139 120 123 268 0 N1  W= 0.10U L= 0.02U
MN140 121 124 269 0 N1  W= 0.10U L= 0.02U
MN141 0 138 122 0 N1  W= 0.10U L= 0.02U
MN142 0 139 123 0 N1  W= 0.10U L= 0.02U
MN143 0 140 124 0 N1  W= 0.10U L= 0.02U
MN144 0 141 125 0 N1  W= 0.10U L= 0.02U
MN145 0 142 126 0 N1  W= 0.10U L= 0.02U
MN146 0 143 127 0 N1  W= 0.10U L= 0.02U
MN147 0 144 128 0 N1  W= 0.10U L= 0.02U
MN148 0 145 129 0 N1  W= 0.10U L= 0.02U
MN149 0 146 130 0 N1  W= 0.10U L= 0.02U
MN150 0 147 131 0 N1  W= 0.10U L= 0.02U
MN151 0 148 132 0 N1  W= 0.10U L= 0.02U
MN152 0 149 133 0 N1  W= 0.10U L= 0.02U
MN153 0 150 134 0 N1  W= 0.10U L= 0.02U
MN154 0 151 135 0 N1  W= 0.10U L= 0.02U
MN155 0 152 136 0 N1  W= 0.10U L= 0.02U
MN156 0 153 137 0 N1  W= 0.10U L= 0.02U
MN157 279 154 0 0 N1  W= 0.11U L= 0.04U
MN158 280 154 0 0 N1  W= 0.11U L= 0.04U
MN159 281 154 0 0 N1  W= 0.11U L= 0.04U
MN160 282 154 0 0 N1  W= 0.11U L= 0.04U
MN161 283 155 0 0 N1  W= 0.11U L= 0.04U
MN162 284 155 0 0 N1  W= 0.11U L= 0.04U
MN163 285 155 0 0 N1  W= 0.11U L= 0.04U
MN164 286 155 0 0 N1  W= 0.11U L= 0.04U
MN165 287 156 0 0 N1  W= 0.11U L= 0.04U
MN166 288 156 0 0 N1  W= 0.11U L= 0.04U
MN167 289 156 0 0 N1  W= 0.11U L= 0.04U
MN168 290 156 0 0 N1  W= 0.11U L= 0.04U
MN169 291 157 0 0 N1  W= 0.11U L= 0.04U
MN170 292 157 0 0 N1  W= 0.11U L= 0.04U
MN171 293 157 0 0 N1  W= 0.11U L= 0.04U
MN172 294 157 0 0 N1  W= 0.11U L= 0.04U
MN173 138 158 279 0 N1  W= 0.10U L= 0.02U
MN174 139 159 280 0 N1  W= 0.10U L= 0.02U
MN175 140 160 281 0 N1  W= 0.10U L= 0.02U
MN176 141 161 282 0 N1  W= 0.10U L= 0.02U
MN177 142 158 283 0 N1  W= 0.10U L= 0.02U
MN178 143 159 284 0 N1  W= 0.10U L= 0.02U
MN179 144 160 285 0 N1  W= 0.10U L= 0.02U
MN180 145 161 286 0 N1  W= 0.10U L= 0.02U
MN181 146 158 287 0 N1  W= 0.10U L= 0.02U
MN182 147 159 288 0 N1  W= 0.10U L= 0.02U
MN183 148 160 289 0 N1  W= 0.10U L= 0.02U
MN184 149 161 290 0 N1  W= 0.10U L= 0.02U
MN185 150 158 291 0 N1  W= 0.10U L= 0.02U
MN186 151 159 292 0 N1  W= 0.10U L= 0.02U
MN187 152 160 293 0 N1  W= 0.10U L= 0.02U
MN188 153 161 294 0 N1  W= 0.10U L= 0.02U
MN189 0 170 154 0 N1  W= 0.10U L= 0.02U
MN190 0 171 155 0 N1  W= 0.10U L= 0.02U
MN191 0 172 156 0 N1  W= 0.10U L= 0.02U
MN192 0 173 157 0 N1  W= 0.10U L= 0.02U
MN193 0 174 158 0 N1  W= 0.10U L= 0.02U
MN194 0 175 159 0 N1  W= 0.10U L= 0.02U
MN195 0 176 160 0 N1  W= 0.10U L= 0.02U
MN196 0 177 161 0 N1  W= 0.10U L= 0.02U
MN197 162 154 0 0 N1  W= 0.10U L= 0.02U
MN198 163 155 0 0 N1  W= 0.10U L= 0.02U
MN199 164 156 0 0 N1  W= 0.10U L= 0.02U
MN200 165 157 0 0 N1  W= 0.10U L= 0.02U
MN201 166 158 0 0 N1  W= 0.10U L= 0.02U
MN202 167 159 0 0 N1  W= 0.10U L= 0.02U
MN203 168 160 0 0 N1  W= 0.10U L= 0.02U
MN204 169 161 0 0 N1  W= 0.10U L= 0.02U
MN205 170 308 162 0 N1  W= 0.10U L= 0.02U
MN206 171 308 163 0 N1  W= 0.10U L= 0.02U
MN207 172 308 164 0 N1  W= 0.10U L= 0.02U
MN208 173 308 165 0 N1  W= 0.10U L= 0.02U
MN209 174 308 166 0 N1  W= 0.10U L= 0.02U
MN210 175 308 167 0 N1  W= 0.10U L= 0.02U
MN211 176 308 168 0 N1  W= 0.10U L= 0.02U
MN212 177 308 169 0 N1  W= 0.10U L= 0.02U
MN213 178 309 170 0 N1  W= 0.10U L= 0.02U
MN214 179 309 171 0 N1  W= 0.10U L= 0.02U
MN215 180 309 172 0 N1  W= 0.10U L= 0.02U
MN216 181 309 173 0 N1  W= 0.10U L= 0.02U
MN217 182 309 174 0 N1  W= 0.10U L= 0.02U
MN218 183 309 175 0 N1  W= 0.10U L= 0.02U
MN219 184 309 176 0 N1  W= 0.10U L= 0.02U
MN220 185 309 177 0 N1  W= 0.10U L= 0.02U
MN221 0 194 178 0 N1  W= 0.10U L= 0.02U
MN222 0 195 179 0 N1  W= 0.10U L= 0.02U
MN223 0 196 180 0 N1  W= 0.10U L= 0.02U
MN224 0 197 181 0 N1  W= 0.10U L= 0.02U
MN225 0 198 182 0 N1  W= 0.10U L= 0.02U
MN226 0 199 183 0 N1  W= 0.10U L= 0.02U
MN227 0 200 184 0 N1  W= 0.10U L= 0.02U
MN228 0 201 185 0 N1  W= 0.10U L= 0.02U
MN229 186 178 0 0 N1  W= 0.10U L= 0.02U
MN230 187 179 0 0 N1  W= 0.10U L= 0.02U
MN231 188 180 0 0 N1  W= 0.10U L= 0.02U
MN232 189 181 0 0 N1  W= 0.10U L= 0.02U
MN233 190 182 0 0 N1  W= 0.10U L= 0.02U
MN234 191 183 0 0 N1  W= 0.10U L= 0.02U
MN235 192 184 0 0 N1  W= 0.10U L= 0.02U
MN236 193 185 0 0 N1  W= 0.10U L= 0.02U
MN237 194 309 186 0 N1  W= 0.10U L= 0.02U
MN238 195 309 187 0 N1  W= 0.10U L= 0.02U
MN239 196 309 188 0 N1  W= 0.10U L= 0.02U
MN240 197 309 189 0 N1  W= 0.10U L= 0.02U
MN241 198 309 190 0 N1  W= 0.10U L= 0.02U
MN242 199 309 191 0 N1  W= 0.10U L= 0.02U
MN243 200 309 192 0 N1  W= 0.10U L= 0.02U
MN244 201 309 193 0 N1  W= 0.10U L= 0.02U
MN245 202 308 194 0 N1  W= 0.10U L= 0.02U
MN246 203 308 195 0 N1  W= 0.10U L= 0.02U
MN247 204 308 196 0 N1  W= 0.10U L= 0.02U
MN248 205 308 197 0 N1  W= 0.10U L= 0.02U
MN249 206 308 198 0 N1  W= 0.10U L= 0.02U
MN250 207 308 199 0 N1  W= 0.10U L= 0.02U
MN251 208 308 200 0 N1  W= 0.10U L= 0.02U
MN252 209 308 201 0 N1  W= 0.10U L= 0.02U
MP1 30 41 1 1 P1  W= 0.14U L= 0.02U
MP2 31 317 1 1 P1  W= 0.14U L= 0.02U
MP3 32 307 1 1 P1  W= 0.14U L= 0.02U
MP4 33 313 1 1 P1  W= 0.14U L= 0.02U
MP5 34 45 1 1 P1  W= 0.14U L= 0.02U
MP6 35 70 30 1 P1  W= 0.14U L= 0.02U
MP7 36 71 31 1 P1  W= 0.14U L= 0.02U
MP8 37 72 32 1 P1  W= 0.14U L= 0.02U
MP9 38 73 33 1 P1  W= 0.14U L= 0.02U
MP10 39 74 34 1 P1  W= 0.14U L= 0.02U
MP11 1 75 35 1 P1  W= 0.14U L= 0.02U
MP12 1 76 36 1 P1  W= 0.14U L= 0.02U
MP13 1 77 37 1 P1  W= 0.14U L= 0.02U
MP14 1 78 38 1 P1  W= 0.14U L= 0.02U
MP15 1 79 39 1 P1  W= 0.14U L= 0.02U
MP16 41 318 1 1 P1  W= 0.14U L= 0.02U
MP17 42 314 1 1 P1  W= 0.14U L= 0.02U
MP18 43 304 1 1 P1  W= 0.14U L= 0.02U
MP19 1 64 40 1 P1  W= 0.14U L= 0.02U
MP20 44 310 1 1 P1  W= 0.14U L= 0.02U
MP21 45 321 1 1 P1  W= 0.14U L= 0.02U
MP22 46 58 1 1 P1  W= 0.14U L= 0.02U
MP23 47 318 1 1 P1  W= 0.14U L= 0.02U
MP24 48 314 1 1 P1  W= 0.14U L= 0.02U
MP25 49 304 1 1 P1  W= 0.14U L= 0.02U
MP26 50 310 1 1 P1  W= 0.14U L= 0.02U
MP27 51 321 1 1 P1  W= 0.14U L= 0.02U
MP28 52 70 47 1 P1  W= 0.14U L= 0.02U
MP29 53 71 48 1 P1  W= 0.14U L= 0.02U
MP30 54 72 49 1 P1  W= 0.14U L= 0.02U
MP31 55 325 1 1 P1  W= 0.14U L= 0.02U
MP32 56 73 50 1 P1  W= 0.14U L= 0.02U
MP33 57 74 51 1 P1  W= 0.14U L= 0.02U
MP34 1 59 52 1 P1  W= 0.14U L= 0.02U
MP35 1 60 53 1 P1  W= 0.14U L= 0.02U
MP36 1 61 54 1 P1  W= 0.14U L= 0.02U
MP37 58 324 55 1 P1  W= 0.14U L= 0.02U
MP38 1 62 56 1 P1  W= 0.14U L= 0.02U
MP39 1 63 57 1 P1  W= 0.14U L= 0.02U
MP40 59 70 1 1 P1  W= 0.14U L= 0.02U
MP41 60 71 1 1 P1  W= 0.14U L= 0.02U
MP42 61 72 1 1 P1  W= 0.14U L= 0.02U
MP43 1 64 58 1 P1  W= 0.14U L= 0.02U
MP44 62 73 1 1 P1  W= 0.14U L= 0.02U
MP45 63 74 1 1 P1  W= 0.14U L= 0.02U
MP46 1 318 59 1 P1  W= 0.14U L= 0.02U
MP47 1 314 60 1 P1  W= 0.14U L= 0.02U
MP48 1 304 61 1 P1  W= 0.14U L= 0.02U
MP49 64 324 1 1 P1  W= 0.14U L= 0.02U
MP50 1 310 62 1 P1  W= 0.14U L= 0.02U
MP51 1 321 63 1 P1  W= 0.14U L= 0.02U
MP52 1 325 64 1 P1  W= 0.14U L= 0.02U
MP53 65 320 1 1 P1  W= 0.14U L= 0.02U
MP54 66 316 1 1 P1  W= 0.14U L= 0.02U
MP55 67 306 1 1 P1  W= 0.14U L= 0.02U
MP56 68 312 1 1 P1  W= 0.14U L= 0.02U
MP57 69 323 1 1 P1  W= 0.14U L= 0.02U
MP58 70 319 65 1 P1  W= 0.14U L= 0.02U
MP59 71 315 66 1 P1  W= 0.14U L= 0.02U
MP60 72 305 67 1 P1  W= 0.14U L= 0.02U
MP61 73 311 68 1 P1  W= 0.14U L= 0.02U
MP62 74 322 69 1 P1  W= 0.14U L= 0.02U
MP63 1 75 70 1 P1  W= 0.14U L= 0.02U
MP64 1 76 71 1 P1  W= 0.14U L= 0.02U
MP65 1 77 72 1 P1  W= 0.14U L= 0.02U
MP66 1 78 73 1 P1  W= 0.14U L= 0.02U
MP67 1 79 74 1 P1  W= 0.14U L= 0.02U
MP68 75 319 1 1 P1  W= 0.14U L= 0.02U
MP69 76 315 1 1 P1  W= 0.14U L= 0.02U
MP70 77 305 1 1 P1  W= 0.14U L= 0.02U
MP71 78 311 1 1 P1  W= 0.14U L= 0.02U
MP72 79 322 1 1 P1  W= 0.14U L= 0.02U
MP73 1 320 75 1 P1  W= 0.14U L= 0.02U
MP74 1 316 76 1 P1  W= 0.14U L= 0.02U
MP75 1 306 77 1 P1  W= 0.14U L= 0.02U
MP76 1 312 78 1 P1  W= 0.14U L= 0.02U
MP77 1 323 79 1 P1  W= 0.14U L= 0.02U
MP78 80 86 1 1 P1  W= 0.14U L= 0.02U
MP79 81 87 1 1 P1  W= 0.14U L= 0.02U
MP80 82 88 1 1 P1  W= 0.14U L= 0.02U
MP81 83 111 80 1 P1  W= 0.14U L= 0.02U
MP82 84 112 81 1 P1  W= 0.14U L= 0.02U
MP83 85 113 82 1 P1  W= 0.14U L= 0.02U
MP84 1 117 83 1 P1  W= 0.14U L= 0.02U
MP85 1 118 84 1 P1  W= 0.14U L= 0.02U
MP86 1 119 85 1 P1  W= 0.14U L= 0.02U
MP87 86 96 1 1 P1  W= 0.14U L= 0.02U
MP88 87 97 1 1 P1  W= 0.14U L= 0.02U
MP89 88 303 1 1 P1  W= 0.14U L= 0.02U
MP90 89 96 1 1 P1  W= 0.14U L= 0.02U
MP91 90 97 1 1 P1  W= 0.14U L= 0.02U
MP92 91 303 1 1 P1  W= 0.14U L= 0.02U
MP93 92 111 89 1 P1  W= 0.14U L= 0.02U
MP94 93 112 90 1 P1  W= 0.14U L= 0.02U
MP95 95 113 91 1 P1  W= 0.14U L= 0.02U
MP96 1 99 92 1 P1  W= 0.14U L= 0.02U
MP97 1 100 93 1 P1  W= 0.14U L= 0.02U
MP98 1 116 94 1 P1  W= 0.14U L= 0.02U
MP99 1 101 95 1 P1  W= 0.14U L= 0.02U
MP100 99 111 1 1 P1  W= 0.14U L= 0.02U
MP101 100 112 1 1 P1  W= 0.14U L= 0.02U
MP102 98 107 1 1 P1  W= 0.14U L= 0.02U
MP103 101 113 1 1 P1  W= 0.14U L= 0.02U
MP104 1 120 96 1 P1  W= 0.14U L= 0.02U
MP105 1 121 97 1 P1  W= 0.14U L= 0.02U
MP106 1 96 99 1 P1  W= 0.14U L= 0.02U
MP107 1 97 100 1 P1  W= 0.14U L= 0.02U
MP108 1 303 101 1 P1  W= 0.14U L= 0.02U
MP109 102 114 1 1 P1  W= 0.14U L= 0.02U
MP110 103 115 1 1 P1  W= 0.14U L= 0.02U
MP111 104 327 1 1 P1  W= 0.14U L= 0.02U
MP112 105 130 1 1 P1  W= 0.14U L= 0.02U
MP113 106 330 1 1 P1  W= 0.14U L= 0.02U
MP114 107 326 104 1 P1  W= 0.14U L= 0.02U
MP115 108 329 1 1 P1  W= 0.14U L= 0.02U
MP116 109 123 1 1 P1  W= 0.14U L= 0.02U
MP117 110 124 1 1 P1  W= 0.14U L= 0.02U
MP118 111 103 105 1 P1  W= 0.14U L= 0.02U
MP119 112 98 106 1 P1  W= 0.14U L= 0.02U
MP120 1 116 107 1 P1  W= 0.14U L= 0.02U
MP121 113 328 108 1 P1  W= 0.14U L= 0.02U
MP122 114 126 109 1 P1  W= 0.14U L= 0.02U
MP123 115 127 110 1 P1  W= 0.14U L= 0.02U
MP124 1 117 111 1 P1  W= 0.14U L= 0.02U
MP125 1 118 112 1 P1  W= 0.14U L= 0.02U
MP126 116 326 1 1 P1  W= 0.14U L= 0.02U
MP127 1 119 113 1 P1  W= 0.14U L= 0.02U
MP128 1 120 114 1 P1  W= 0.14U L= 0.02U
MP129 1 121 115 1 P1  W= 0.14U L= 0.02U
MP130 117 103 1 1 P1  W= 0.14U L= 0.02U
MP131 118 98 1 1 P1  W= 0.14U L= 0.02U
MP132 1 327 116 1 P1  W= 0.14U L= 0.02U
MP133 119 328 1 1 P1  W= 0.14U L= 0.02U
MP134 120 126 1 1 P1  W= 0.14U L= 0.02U
MP135 121 127 1 1 P1  W= 0.14U L= 0.02U
MP136 1 130 117 1 P1  W= 0.14U L= 0.02U
MP137 1 330 118 1 P1  W= 0.14U L= 0.02U
MP138 1 329 119 1 P1  W= 0.14U L= 0.02U
MP139 1 123 120 1 P1  W= 0.14U L= 0.02U
MP140 1 124 121 1 P1  W= 0.14U L= 0.02U
MP141 1 138 122 1 P1  W= 0.14U L= 0.02U
MP142 1 139 123 1 P1  W= 0.14U L= 0.02U
MP143 1 140 124 1 P1  W= 0.14U L= 0.02U
MP144 1 141 125 1 P1  W= 0.14U L= 0.02U
MP145 1 142 126 1 P1  W= 0.14U L= 0.02U
MP146 1 143 127 1 P1  W= 0.14U L= 0.02U
MP147 1 144 128 1 P1  W= 0.14U L= 0.02U
MP148 1 145 129 1 P1  W= 0.14U L= 0.02U
MP149 1 146 130 1 P1  W= 0.14U L= 0.02U
MP150 1 147 131 1 P1  W= 0.14U L= 0.02U
MP151 1 148 132 1 P1  W= 0.14U L= 0.02U
MP152 1 149 133 1 P1  W= 0.14U L= 0.02U
MP153 1 150 134 1 P1  W= 0.14U L= 0.02U
MP154 1 151 135 1 P1  W= 0.14U L= 0.02U
MP155 1 152 136 1 P1  W= 0.14U L= 0.02U
MP156 1 153 137 1 P1  W= 0.14U L= 0.02U
MP157 138 154 1 1 P1  W= 0.14U L= 0.02U
MP158 139 154 1 1 P1  W= 0.14U L= 0.02U
MP159 140 154 1 1 P1  W= 0.14U L= 0.02U
MP160 141 154 1 1 P1  W= 0.14U L= 0.02U
MP161 142 155 1 1 P1  W= 0.14U L= 0.02U
MP162 143 155 1 1 P1  W= 0.14U L= 0.02U
MP163 144 155 1 1 P1  W= 0.14U L= 0.02U
MP164 145 155 1 1 P1  W= 0.14U L= 0.02U
MP165 146 156 1 1 P1  W= 0.14U L= 0.02U
MP166 147 156 1 1 P1  W= 0.14U L= 0.02U
MP167 148 156 1 1 P1  W= 0.14U L= 0.02U
MP168 149 156 1 1 P1  W= 0.14U L= 0.02U
MP169 150 157 1 1 P1  W= 0.14U L= 0.02U
MP170 151 157 1 1 P1  W= 0.14U L= 0.02U
MP171 152 157 1 1 P1  W= 0.14U L= 0.02U
MP172 153 157 1 1 P1  W= 0.14U L= 0.02U
MP173 1 158 138 1 P1  W= 0.15U L= 0.04U
MP174 1 159 139 1 P1  W= 0.15U L= 0.04U
MP175 1 160 140 1 P1  W= 0.15U L= 0.04U
MP176 1 161 141 1 P1  W= 0.15U L= 0.04U
MP177 1 158 142 1 P1  W= 0.15U L= 0.04U
MP178 1 159 143 1 P1  W= 0.15U L= 0.04U
MP179 1 160 144 1 P1  W= 0.15U L= 0.04U
MP180 1 161 145 1 P1  W= 0.15U L= 0.04U
MP181 1 158 146 1 P1  W= 0.15U L= 0.04U
MP182 1 159 147 1 P1  W= 0.15U L= 0.04U
MP183 1 160 148 1 P1  W= 0.15U L= 0.04U
MP184 1 161 149 1 P1  W= 0.15U L= 0.04U
MP185 1 158 150 1 P1  W= 0.15U L= 0.04U
MP186 1 159 151 1 P1  W= 0.15U L= 0.04U
MP187 1 160 152 1 P1  W= 0.15U L= 0.04U
MP188 1 161 153 1 P1  W= 0.15U L= 0.04U
MP189 1 170 154 1 P1  W= 0.14U L= 0.02U
MP190 1 171 155 1 P1  W= 0.14U L= 0.02U
MP191 1 172 156 1 P1  W= 0.14U L= 0.02U
MP192 1 173 157 1 P1  W= 0.14U L= 0.02U
MP193 1 174 158 1 P1  W= 0.14U L= 0.02U
MP194 1 175 159 1 P1  W= 0.14U L= 0.02U
MP195 1 176 160 1 P1  W= 0.14U L= 0.02U
MP196 1 177 161 1 P1  W= 0.14U L= 0.02U
MP197 162 154 1 1 P1  W= 0.14U L= 0.02U
MP198 163 155 1 1 P1  W= 0.14U L= 0.02U
MP199 164 156 1 1 P1  W= 0.14U L= 0.02U
MP200 165 157 1 1 P1  W= 0.14U L= 0.02U
MP201 166 158 1 1 P1  W= 0.14U L= 0.02U
MP202 167 159 1 1 P1  W= 0.14U L= 0.02U
MP203 168 160 1 1 P1  W= 0.14U L= 0.02U
MP204 169 161 1 1 P1  W= 0.14U L= 0.02U
MP205 170 309 162 1 P1  W= 0.14U L= 0.02U
MP206 171 309 163 1 P1  W= 0.14U L= 0.02U
MP207 172 309 164 1 P1  W= 0.14U L= 0.02U
MP208 173 309 165 1 P1  W= 0.14U L= 0.02U
MP209 174 309 166 1 P1  W= 0.14U L= 0.02U
MP210 175 309 167 1 P1  W= 0.14U L= 0.02U
MP211 176 309 168 1 P1  W= 0.14U L= 0.02U
MP212 177 309 169 1 P1  W= 0.14U L= 0.02U
MP213 178 308 170 1 P1  W= 0.14U L= 0.02U
MP214 179 308 171 1 P1  W= 0.14U L= 0.02U
MP215 180 308 172 1 P1  W= 0.14U L= 0.02U
MP216 181 308 173 1 P1  W= 0.14U L= 0.02U
MP217 182 308 174 1 P1  W= 0.14U L= 0.02U
MP218 183 308 175 1 P1  W= 0.14U L= 0.02U
MP219 184 308 176 1 P1  W= 0.14U L= 0.02U
MP220 185 308 177 1 P1  W= 0.14U L= 0.02U
MP221 1 194 178 1 P1  W= 0.14U L= 0.02U
MP222 1 195 179 1 P1  W= 0.14U L= 0.02U
MP223 1 196 180 1 P1  W= 0.14U L= 0.02U
MP224 1 197 181 1 P1  W= 0.14U L= 0.02U
MP225 1 198 182 1 P1  W= 0.14U L= 0.02U
MP226 1 199 183 1 P1  W= 0.14U L= 0.02U
MP227 1 200 184 1 P1  W= 0.14U L= 0.02U
MP228 1 201 185 1 P1  W= 0.14U L= 0.02U
MP229 186 178 1 1 P1  W= 0.14U L= 0.02U
MP230 187 179 1 1 P1  W= 0.14U L= 0.02U
MP231 188 180 1 1 P1  W= 0.14U L= 0.02U
MP232 189 181 1 1 P1  W= 0.14U L= 0.02U
MP233 190 182 1 1 P1  W= 0.14U L= 0.02U
MP234 191 183 1 1 P1  W= 0.14U L= 0.02U
MP235 192 184 1 1 P1  W= 0.14U L= 0.02U
MP236 193 185 1 1 P1  W= 0.14U L= 0.02U
MP237 209 309 201 1 P1  W= 0.14U L= 0.02U
MP238 208 309 200 1 P1  W= 0.14U L= 0.02U
MP239 207 309 199 1 P1  W= 0.14U L= 0.02U
MP240 206 309 198 1 P1  W= 0.14U L= 0.02U
MP241 205 309 197 1 P1  W= 0.14U L= 0.02U
MP242 204 309 196 1 P1  W= 0.14U L= 0.02U
MP243 203 309 195 1 P1  W= 0.14U L= 0.02U
MP244 202 309 194 1 P1  W= 0.14U L= 0.02U
MP245 201 308 193 1 P1  W= 0.14U L= 0.02U
MP246 200 308 192 1 P1  W= 0.14U L= 0.02U
MP247 199 308 191 1 P1  W= 0.14U L= 0.02U
MP248 198 308 190 1 P1  W= 0.14U L= 0.02U
MP249 197 308 189 1 P1  W= 0.14U L= 0.02U
MP250 196 308 188 1 P1  W= 0.14U L= 0.02U
MP251 195 308 187 1 P1  W= 0.14U L= 0.02U
MP252 194 308 186 1 P1  W= 0.14U L= 0.02U
*
C2 1 0  0.199fF
C3 1 0  0.199fF
C4 1 0  0.199fF
C5 1 0  0.199fF
C6 1 0  0.199fF
C7 1 0  0.199fF
C8 1 0  0.199fF
C9 1 0  0.199fF
C10 1 0  0.229fF
C11 1 0  0.229fF
C12 1 0  0.229fF
C13 1 0  0.229fF
C14 1 0  0.229fF
C15 1 0  0.229fF
C16 1 0  0.229fF
C17 1 0  0.229fF
C18 1 0  0.267fF
C19 1 0  0.498fF
C20 1 0  0.498fF
C21 1 0  0.267fF
C22 1 0  0.498fF
C23 1 0  0.267fF
C24 1 0  0.498fF
C25 1 0  0.267fF
C26 1 0  0.498fF
C27 1 0  0.498fF
C28 1 0  0.498fF
C29 1 0  0.498fF
C30 30 0  0.023fF
C31 31 0  0.023fF
C32 32 0  0.023fF
C33 33 0  0.023fF
C34 34 0  0.023fF
C35 35 0  0.096fF
C36 36 0  0.096fF
C37 37 0  0.096fF
C38 38 0  0.096fF
C39 39 0  0.096fF
C40 40 0  0.105fF
C41 41 0  0.133fF
C42 42 0  0.103fF
C43 43 0  0.103fF
C44 44 0  0.094fF
C45 45 0  0.133fF
C46 46 0  0.109fF
C47 47 0  0.023fF
C48 48 0  0.023fF
C49 49 0  0.023fF
C50 50 0  0.023fF
C51 51 0  0.023fF
C52 52 0  0.124fF
C53 53 0  0.124fF
C54 54 0  0.124fF
C55 55 0  0.023fF
C56 56 0  0.124fF
C57 57 0  0.124fF
C58 58 0  0.111fF
C59 59 0  0.095fF
C60 60 0  0.095fF
C61 61 0  0.095fF
C62 62 0  0.095fF
C63 63 0  0.095fF
C64 64 0  0.148fF
C65 65 0  0.023fF
C66 66 0  0.023fF
C67 67 0  0.023fF
C68 68 0  0.023fF
C69 69 0  0.023fF
C70 70 0  0.191fF
C71 71 0  0.191fF
C72 72 0  0.191fF
C73 73 0  0.191fF
C74 74 0  0.191fF
C75 75 0  0.194fF
C76 76 0  0.194fF
C77 77 0  0.194fF
C78 78 0  0.194fF
C79 79 0  0.194fF
C80 80 0  0.023fF
C81 81 0  0.023fF
C82 82 0  0.023fF
C83 83 0  0.096fF
C84 84 0  0.096fF
C85 85 0  0.096fF
C86 86 0  0.133fF
C87 87 0  0.133fF
C88 88 0  0.133fF
C89 89 0  0.023fF
C90 90 0  0.023fF
C91 91 0  0.023fF
C92 92 0  0.124fF
C93 93 0  0.124fF
C94 94 0  0.105fF
C95 95 0  0.124fF
C96 96 0  0.262fF
C97 97 0  0.259fF
C98 98 0  0.344fF
C99 99 0  0.095fF
C100 100 0  0.095fF
C101 101 0  0.095fF
C102 102 0  0.109fF
C103 103 0  0.336fF
C104 104 0  0.023fF
C105 105 0  0.023fF
C106 106 0  0.023fF
C107 107 0  0.111fF
C108 108 0  0.023fF
C109 109 0  0.023fF
C110 110 0  0.023fF
C111 111 0  0.191fF
C112 112 0  0.191fF
C113 113 0  0.191fF
C114 114 0  0.111fF
C115 115 0  0.111fF
C116 116 0  0.148fF
C117 117 0  0.194fF
C118 118 0  0.194fF
C119 119 0  0.194fF
C120 120 0  0.148fF
C121 121 0  0.148fF
C122 122 0  0.386fF
C123 123 0  0.154fF
C124 124 0  0.223fF
C125 125 0  0.073fF
C126 126 0  0.243fF
C127 127 0  0.147fF
C128 128 0  0.073fF
C129 129 0  0.073fF
C130 130 0  0.245fF
C131 131 0  0.073fF
C132 132 0  0.073fF
C133 133 0  0.073fF
C134 134 0  0.073fF
C135 135 0  0.073fF
C136 136 0  0.073fF
C137 137 0  0.073fF
C138 138 0  0.097fF
C139 139 0  0.097fF
C140 140 0  0.097fF
C141 141 0  0.097fF
C142 142 0  0.097fF
C143 143 0  0.097fF
C144 144 0  0.097fF
C145 145 0  0.097fF
C146 146 0  0.097fF
C147 147 0  0.097fF
C148 148 0  0.097fF
C149 149 0  0.097fF
C150 150 0  0.097fF
C151 151 0  0.097fF
C152 152 0  0.097fF
C153 153 0  0.097fF
C154 154 0  0.328fF
C155 155 0  0.427fF
C156 156 0  0.407fF
C157 157 0  0.452fF
C158 158 0  0.516fF
C159 159 0  0.545fF
C160 160 0  0.555fF
C161 161 0  0.563fF
C162 162 0  0.080fF
C163 163 0  0.080fF
C164 164 0  0.080fF
C165 165 0  0.080fF
C166 166 0  0.080fF
C167 167 0  0.080fF
C168 168 0  0.080fF
C169 169 0  0.080fF
C170 170 0  0.093fF
C171 171 0  0.093fF
C172 172 0  0.093fF
C173 173 0  0.093fF
C174 174 0  0.093fF
C175 175 0  0.093fF
C176 176 0  0.093fF
C177 177 0  0.093fF
C178 178 0  0.098fF
C179 179 0  0.098fF
C180 180 0  0.098fF
C181 181 0  0.098fF
C182 182 0  0.098fF
C183 183 0  0.098fF
C184 184 0  0.098fF
C185 185 0  0.098fF
C186 186 0  0.080fF
C187 187 0  0.080fF
C188 188 0  0.080fF
C189 189 0  0.080fF
C190 190 0  0.080fF
C191 191 0  0.080fF
C192 192 0  0.080fF
C193 193 0  0.080fF
C194 194 0  0.093fF
C195 195 0  0.093fF
C196 196 0  0.093fF
C197 197 0  0.093fF
C198 198 0  0.093fF
C199 199 0  0.093fF
C200 200 0  0.093fF
C201 201 0  0.093fF
C202 202 0  0.085fF
C203 203 0  0.085fF
C204 204 0  0.085fF
C205 205 0  0.085fF
C206 206 0  0.085fF
C207 207 0  0.085fF
C208 208 0  0.085fF
C209 209 0  0.085fF
C210 210 0  0.061fF
C211 211 0  0.061fF
C212 212 0  0.061fF
C213 213 0  0.061fF
C214 214 0  0.061fF
C221 221 0  0.067fF
C222 222 0  0.067fF
C223 223 0  0.067fF
C224 224 0  0.067fF
C225 225 0  0.067fF
C226 226 0  0.067fF
C227 227 0  0.018fF
C228 228 0  0.018fF
C229 229 0  0.018fF
C230 230 0  0.018fF
C231 231 0  0.018fF
C232 232 0  0.018fF
C233 233 0  0.067fF
C234 234 0  0.067fF
C235 235 0  0.067fF
C236 236 0  0.067fF
C237 237 0  0.067fF
C238 238 0  0.018fF
C239 239 0  0.018fF
C240 240 0  0.018fF
C241 241 0  0.018fF
C242 242 0  0.018fF
C243 243 0  0.061fF
C244 244 0  0.061fF
C245 245 0  0.061fF
C249 249 0  0.067fF
C250 250 0  0.067fF
C251 251 0  0.067fF
C253 253 0  0.018fF
C254 254 0  0.018fF
C255 255 0  0.018fF
C258 258 0  0.067fF
C259 259 0  0.067fF
C260 260 0  0.067fF
C261 261 0  0.067fF
C262 262 0  0.067fF
C263 263 0  0.067fF
C264 264 0  0.018fF
C265 265 0  0.018fF
C266 266 0  0.018fF
C267 267 0  0.018fF
C268 268 0  0.018fF
C269 269 0  0.018fF
C279 279 0  0.028fF
C280 280 0  0.026fF
C281 281 0  0.028fF
C282 282 0  0.026fF
C283 283 0  0.028fF
C284 284 0  0.026fF
C285 285 0  0.028fF
C286 286 0  0.026fF
C287 287 0  0.028fF
C288 288 0  0.026fF
C289 289 0  0.028fF
C290 290 0  0.026fF
C291 291 0  0.028fF
C292 292 0  0.026fF
C293 293 0  0.028fF
C294 294 0  0.026fF
C303 303 0  0.128fF
C304 304 0  0.128fF
C305 305 0  0.049fF
C306 306 0  0.058fF
C307 307 0  0.015fF
C308 308 0  1.321fF
C309 309 0  1.327fF
C310 310 0  0.128fF
C311 311 0  0.049fF
C312 312 0  0.058fF
C313 313 0  0.030fF
C314 314 0  0.128fF
C315 315 0  0.049fF
C316 316 0  0.058fF
C317 317 0  0.015fF
C318 318 0  0.128fF
C319 319 0  0.049fF
C320 320 0  0.058fF
C321 321 0  0.128fF
C322 322 0  0.049fF
C323 323 0  0.058fF
C324 324 0  0.051fF
C325 325 0  0.058fF
C326 326 0  0.051fF
C327 327 0  0.058fF
C328 328 0  0.049fF
C329 329 0  0.058fF
C330 330 0  0.119fF
C331 331 0  0.030fF
C332 332 0  0.030fF
C333 333 0  0.030fF
C334 334 0  0.030fF
C335 335 0  0.030fF
C336 336 0  0.030fF
C337 337 0  0.030fF
C338 338 0  0.030fF
*
*
* n-MOS BSIM4 :
* low leakage
.MODEL N1 NMOS LEVEL=14 VTHO=0.18 U0=0.050 TOXE= 1.5E-9 LINT=0.000U
+K1 =0.450 K2=0.100 DVT0=2.300
+DVT1=0.540 LPE0=0.200e-9 ETA0=0.080
+NFACTOR=  1.6 U0=0.050 UA=3.000e-15
+WINT=0.020U LPE0=0.200e-9
+KT1=-0.060 UTE=-1.800 VOFF=0.010
+XJ=0.150U NDEP=170.000e15 PCLM=1.100
+CGSO=100.0p CGDO=100.0p
+CGBO= 60.0p
*
* p-MOS BSIM4:
* low leakage
.MODEL P1 PMOS LEVEL=14 VTHO=-0.18 U0=0.028 TOXE= 1.5E-9 LINT=0.000U
+K1 =0.450 K2=0.100 DVT0=2.300
+DVT1=0.540 LPE0=0.200e-9 ETA0=0.080
+NFACTOR=  1.6 U0=0.028 UA=3.000e-15
+WINT=0.020U LPE0=0.200e-9
+KT1=-0.060 UTE=-1.800 VOFF=0.010
+XJ=0.150U NDEP=170.000e15 PCLM=0.700
+CGSO=100.0p CGDO=100.0p
+CGBO= 60.0p
*
* Transient analysis
*
* (Winspice)
.options temp=27.0
.control
tran 0.1N 1.00N
print  V(202) V(309) V(308) V(154) V(155) V(203) V(205) V(157) V(156) V(204) V(206) V(158) V(159) V(207) V(209) V(161) V(160) V(208) V(325) V(324) V(40) V(46) V(305) V(306) V(304) V(37) V(54) V(56) V(38) V(310) V(312) V(311) V(53) V(36) V(314) V(316) V(315) V(5 > out.txt
plot  V(202) V(309) V(308) V(154) V(155) V(203) V(205) V(157) V(156) V(204) V(206) V(158) V(159) V(207) V(209) V(161) V(160) V(208) V(325) V(324) V(40) V(46) V(305) V(306) V(304) V(37) V(54) V(56) V(38) V(310) V(312) V(311) V(53) V(36) V(314) V(316) V(315) V(5
.endc
.END
